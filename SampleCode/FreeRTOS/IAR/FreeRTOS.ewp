# IAR project FreeRTOS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\Library\CMSIS\Core\Include; $PROJ_DIR$..\..\..\..\Library\Device\Nuvoton\M031\Include; $PROJ_DIR$..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\Library\CMSIS\Core\Include; $PROJ_DIR$..\..\..\..\Library\Device\Nuvoton\M031\Include; $PROJ_DIR$..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\
  OBJCOPY.OOCOutputFile: FreeRTOS.bin
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: flash.c PollQ.c QueueSet.c
    ../: main.c ParTest.c

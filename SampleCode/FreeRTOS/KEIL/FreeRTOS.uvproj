# Keil uVision project FreeRTOS.uvproj, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M031SIAAE Nuvoton
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM0;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group System
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c PollQ.c flash.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c

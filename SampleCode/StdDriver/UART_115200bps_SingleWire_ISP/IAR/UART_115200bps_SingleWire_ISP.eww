<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\UART_115200bps_SingleWire_ISP.ewp</path>
  </project>
  <batchBuild/>
</workspace>



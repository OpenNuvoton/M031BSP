# IAR project USBD_Audio_NAU8822_Microphone.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio_NAU8822_Microphone.bin
  ILINK.IlinkOutputFile: USBD_Audio_NAU8822.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration UAC_Microphone (ARM)
  as the first configuration, except:
configuration UAC_Microphone_Mediakey (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __HID__; __MEDIAKEY__
configuration UAC_Microphone_Joystick (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __HID__; __JOYSTICK__
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c retarget.c spi.c sys.c uart.c usbd.c
  group User
    ../: descriptors.c hid.c main.c usbd_audio.c

# IAR project USBD_HID_Transfer_And_MSC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_Transfer_And_MSC.bin
  ILINK.IlinkOutputFile: USBD_HID_Transfer_And_MSC.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c usbd.c
  group User
    ../: DataFlashProg.c descriptors.c HID_Transfer_and_MSC.c main.c

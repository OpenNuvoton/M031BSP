# IAR project PWM_Brake.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_Brake.bin
  ILINK.IlinkOutputFile: PWM_Brake.out
  ILINK.IlinkIcfFile: PWM_Brake.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c pwm.c retarget.c sys.c uart.c
  group User
    ../: main.c

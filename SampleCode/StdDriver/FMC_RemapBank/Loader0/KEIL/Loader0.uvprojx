# Keil uVision project Loader0.uvprojx, settings and files
target Loader0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Loader0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: M031_I
  c include: ..\..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c fmc.c

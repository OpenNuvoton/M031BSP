# IAR project SYS_PowerDown_MinCurrent.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PowerDown_MinCurrent.bin
  ILINK.IlinkOutputFile: SYS_PowerDown_MinCurrent.out
  ILINK.IlinkIcfFile: SYS_PowerDown_MinCurrent.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library Files
    ../../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
  group Source Files
    ../: main.c

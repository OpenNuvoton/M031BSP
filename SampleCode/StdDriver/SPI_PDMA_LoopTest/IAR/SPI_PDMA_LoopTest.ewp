# IAR project SPI_PDMA_LoopTest.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_PDMA_LoopTest.bin
  ILINK.IlinkOutputFile: SPI_PDMA_LoopTest.out
  ILINK.IlinkIcfFile: SPI_PDMA_LoopTest.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c pdma.c retarget.c spi.c sys.c uart.c
  group Source Files
    ../: main.c

# IAR project emWin_SimpleDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEMO_320x240__; __GUI_NUMBTYES__=12
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\emWin\Config; ..\..\..\..\ThirdParty\emWin\Include; ..\..\..\..\Library\NuMaker\emWin\lcm; ..\..\..\..\Library\NuMaker\emWin\tslib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emWin_SimpleDemo.bin
  ILINK.IlinkOutputFile: emWin_SimpleDemo.out
  ILINK.IlinkIcfFile: emWin_SimpleDemo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../Application/: FramewinDLG.c
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Config
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM0_IAR.a
  group lcm
    ../../../../Library/NuMaker/emWin/lcm/: ILI9341.c lcm.h ST7735.c
  group Library Files
    ../../../../Library/StdDriver/src/: adc.c clk.c fmc.c gpio.c pdma.c retarget.c sys.c timer.c uart.c usci_spi.c
  group Source Files
    ../: main.c
  group tslib
    ../../../../Library/NuMaker/emWin/tslib/: fbutils.c fbutils.h nuvoton_logo.c testutils.c testutils.h TouchPanel.c TouchPanel.h ts_calibrate.c tslib-filter.h tslib-private.h tslib.h

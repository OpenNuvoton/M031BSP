# Keil uVision project emWin_GUIDemo.uvproj, settings and files
target emWin_GUIDemo_ILI9341 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M032KIAAE Nuvoton
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: emWin_GUIDemo_ILI9341
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEMO_320x240__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\..\..\..\Library\NuMaker\emWin\tslib;..\..\..\..\Library\NuMaker\emWin\lcm
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c uart.c fmc.c adc.c usci_spi.c pdma.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM0_Keil.lib
  group Application
    ../Application/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group tslib
    ../../../../Library/NuMaker/emWin/tslib/: fbutils.c TouchPanel.c testutils.c ts_calibrate.c nuvoton_logo.c
  group lcm
    ../../../../Library/NuMaker/emWin/lcm/: ILI9341.c ST7735.c
target emWin_GUIDemo_ST7735 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M032KIAAE Nuvoton
  cpu: as above
  output: emWin_GUIDemo_ST7735
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEMO_160x128__ __DEMO2__
  c include: as above
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: as above

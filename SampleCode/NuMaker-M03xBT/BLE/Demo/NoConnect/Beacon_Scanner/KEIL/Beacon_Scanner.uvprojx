# Keil uVision project Beacon_Scanner.uvprojx, settings and files
target Beacon_Scanner (ARM-ADS)
  device: M032LE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: Beacon_Scanner +hex
  AfterMake: fromelf --bincombined ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=3
  c include: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\Source\Include;..\..\..\..\Source\Porting;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c pdma.c retarget.c spi.c sys.c timer.c uart.c wdt.c
  group User
    ../: main.c user.c
  group BLE Lib
    ../../../../Source/Lib/: ble_msgblock.c ble_bonding_storage.c ble_LL_ref.c BLELIB_Keil_NOCONN.lib
  group Porting
    ../../../../Source/Porting/: mcu_definition.h porting_flash.c porting_misc.c porting_rfpower.c porting_spi.c dev_addr.c

# Keil uVision project Custom_Beacon.uvproj, settings and files
target Custom_Beacon (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032LE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: Custom_Beacon +hex
  AfterMake: fromelf --bincombined ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\Source;..\..\..\..\Source\Include;..\..\..\..\Source\Lib;..\..\..\..\Source\Porting;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../../../../Library/StdDriver/src/: clk.c gpio.c pdma.c retarget.c spi.c sys.c timer.c uart.c wdt.c fmc.c
  group User
    ../: main.c user.c
  group BLE Lib
    ../../../../Source/Lib/: ble_msgblock.c ble_bonding_storage.c ble_LL_ref.c BLELIB_NOCONN.lib
  group Porting
    ../../../../source/Porting/: mcu_definition.h porting_flash.c porting_misc.c porting_spi.c porting_rfpower.c
    ../../../../Source/Porting/: dev_addr.c

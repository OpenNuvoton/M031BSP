<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TRSP_UART_HRS.ewp</path>
    </project>
    <batchBuild />
</workspace>

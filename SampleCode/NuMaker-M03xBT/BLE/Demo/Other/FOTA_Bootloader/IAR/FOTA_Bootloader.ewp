# IAR project FOTA_Bootloader.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _BOOT_LOADER_
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Source\Porting; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FOTA_Bootloader.bin
  ILINK.IlinkOutputFile: FOTA_Bootloader.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\Toolchain\IAR\M031.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library Files
    ../../../../../../../Library/StdDriver/src/: fmc.c retarget.c
  group Porting
    ../../../../Source/Porting/: mcu_definition.h porting_flash.c
  group User
    ../: main.c

# Keil uVision project FOTA_Bootloader.uvprojx, settings and files
target FOTA_Bootloader (ARM-ADS)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: FOTA_Bootloader
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: _BOOT_LOADER_
  c include: ..\..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\Source\Porting
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../../../../Library/StdDriver/src/: fmc.c retarget.c
  group User
    ../: main.c
  group Porting
    ../../../../Source/Porting/: porting_flash.c mcu_definition.h

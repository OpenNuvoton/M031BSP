<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ATCMD_Peripheral.ewp</path>
  </project>
  <batchBuild/>
</workspace>



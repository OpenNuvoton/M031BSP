# IAR project HOGP_Peripheral.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M031\Include; ..\..\..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Source\Include; ..\..\..\..\Source\Porting; ..\..\..\..\Source\Service\BleServiceBase; ..\..\..\..\Source\Service\GAP; ..\..\..\..\Source\Service\GATT; ..\..\..\..\Source\Service\DIS; ..\..\..\..\Source\Service\BAS; ..; ..\BleAppProfile; ..\..\..\..\Source\Service\HID_KB_MS_CS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HOGP_Peripheral.bin
  ILINK.IlinkOutputFile: HOGP_Peripheral.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\Toolchain\IAR\M032_Bonding.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group BLE Lib
    ../../../../Source/Lib/: ble_bonding_storage.c ble_LL_ref.c ble_msgblock.c BLELIB_IAR_P.a
  group CMSIS Files
    ../../../../../../../Library/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../../../../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
  group Library Files
    ../../../../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c pdma.c retarget.c spi.c sys.c timer.c uart.c wdt.c
  group Porting
    ../../../../Source/Porting/: dev_addr.c mcu_definition.h porting_flash.c porting_misc.c porting_rfpower.c porting_spi.c
  group Service
    ../../../../Source/Service/BAS/: ble_service_bas.c
    ../../../../Source/Service/BleServiceBase/: ble_service_base.c
    ../../../../Source/Service/DIS/: ble_service_dis.c
    ../../../../Source/Service/GAP/: ble_service_gap.c
    ../../../../Source/Service/GATT/: ble_service_gatt.c
    ../../../../Source/Service/HID_KB_MS_CS/: ble_service_hid_kb_ms_cs.c
  group User
    ../BleAppProfile/: ble_profile_app.c ble_profile_def.c
    ../: BleAppSetting.h main.c user.c

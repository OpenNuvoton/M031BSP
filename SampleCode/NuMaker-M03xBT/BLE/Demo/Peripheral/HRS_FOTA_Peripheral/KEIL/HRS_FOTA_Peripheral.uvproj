# Keil uVision project HRS_FOTA_Peripheral.uvproj, settings and files
target HRS_FOTA_Peripheral (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032LE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: HRS_FOTA_Peripheral +hex
  AfterMake: fromelf --bincombined ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\Source;..\..\..\..\Source\Include;..\..\..\..\Source\Lib;..\..\..\..\Source\Porting;..;..\OTA;..\BleAppProfile;..\..\..\..\Source\Service\BleServiceBase;..\..\..\..\Source\Service\GAP;..\..\..\..\Source\Service\GATT;..\..\..\..\Source\Service\DIS;..\..\..\..\Source\Service\HRS;..\..\..\..\Source\Service\FOTA
  asm define: Stack_Size=1024
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c pdma.c retarget.c spi.c sys.c timer.c uart.c wdt.c
  group User
    ../: main.c user.c BleAppSetting.h
    ../BleAppProfile/: ble_profile_def.c ble_profile_app.c
  group OTA
    ../OTA/: fota.c
  group BLE Lib
    ../../../../Source/Lib/: ble_msgblock.c ble_bonding_storage.c ble_LL_ref.c BLELIB_P.lib
  group Service
    ../../../../Source/Service/BleServiceBase/: ble_service_base.c
    ../../../../Source/Service/GAP/: ble_service_gap.c
    ../../../../Source/Service/GATT/: ble_service_gatt.c
    ../../../../Source/Service/DIS/: ble_service_dis.c
    ../../../../Source/Service/HRS/: ble_service_hrs.c
    ../../../../Source/Service/FOTA/: ble_service_fota.c
  group Porting
    ../../../../Source/Porting/: mcu_definition.h porting_flash.c porting_misc.c porting_rfpower.c porting_spi.c dev_addr.c

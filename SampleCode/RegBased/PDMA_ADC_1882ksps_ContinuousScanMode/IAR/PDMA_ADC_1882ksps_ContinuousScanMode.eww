<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PDMA_ADC_1882ksps_ContinuousScanMode.ewp</path>
  </project>
  <batchBuild/>
</workspace>



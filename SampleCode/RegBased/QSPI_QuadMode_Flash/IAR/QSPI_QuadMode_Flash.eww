<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\QSPI_QuadMode_Flash.ewp</path>
  </project>
  <batchBuild/>
</workspace>


